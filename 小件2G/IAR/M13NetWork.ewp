# IAR project M13NetWork.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32LG280F128 EnergyMicro EFM32LG280F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EFM32LG280F128
  ICCARM.CCIncludePath2: Source\CMSIS\Include\; Source\Device\SiliconLabs\EFM32LG\Include\; Source\Device\SiliconLabs\EFM32LG\Source\; Source\Device\SiliconLabs\EFM32LG\Source\IAR\; Source\emlib\inc\; Source\emlib\src\; Source\M13NetWork\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: M13NetWork_ftp3.bin
  ILINK.IlinkOutputFile: M13NetWork.out
  ILINK.IlinkIcfFile: M13NetWork.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    Source/Device/SiliconLabs/EFM32LG/Source/IAR/: startup_efm32lg.s
    Source/Device/SiliconLabs/EFM32LG/Source/: system_efm32lg.c
  group emlib
    Source/emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_core.c em_cryotimer.c em_crypto.c em_csen.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpcrc.c em_gpio.c em_i2c.c em_idac.c em_int.c em_lcd.c em_ldma.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_rtcc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_vdac.c em_wdog.c
  group M13NetWork
    Source/M13NetWork/: AES.c aP89085.c Base64.c Bluetooth.c board.c flash.c LED.c main.c MCB.c MCU.c money.c SIM800.c
